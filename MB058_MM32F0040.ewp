# IAR project MB058_MM32F0040.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MM32F0040B1T MindMotion MM32F0040B1T
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: MM32SPIN05PF; USE_IAR; _DLIB_FILE_DESCRIPTOR; __ALIGNED
  ICCARM.CCDiagSuppress: Pa082,Pa089
  ICCARM.CCIncludePath2: App\inc; Board\inc; Lib\HAL_Lib\Inc; Lib\Core\IAR_Core; Lib\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MB058_MM32F0040.srec
  ILINK.IlinkOutputFile: MB058_MM32F0040.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group App
    App/: hci.c main.c music.c
  group Board
    Board/: bsp.c bsp_adc.c bsp_beep.c bsp_delay.c bsp_eeprom.c bsp_flash.c bsp_key.c bsp_led.c bsp_uart.c
  group HAL_Lib
    Lib/HAL_Lib/Src/: hal_adc.c hal_comp.c hal_crc.c hal_dbg.c hal_div.c hal_dma.c hal_exti.c hal_flash.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_misc.c hal_pwr.c hal_rcc.c hal_spi.c hal_tim.c hal_uart.c hal_uid.c hal_ver.c hal_wwdg.c
  group STARTUP
    Lib/CMSIS/IAR_StartAsm/: startup_mm32spin0x_q_iar.s
    Lib/CMSIS/: system_mm32spin0x_q.c
