<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\MB058_MM32F0040.ewp</path>
  </project>
  <batchBuild/>
</workspace>


