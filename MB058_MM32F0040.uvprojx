# Keil uVision project MB058_MM32F0040.uvprojx, settings and files
target MB058_MM32F0040 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MM32F0040B1T MindMotion
  pack: MindMotion.MM32F0040_DFP.0.0.3
  cpu: IROM(0x08000000,0x00008000) IRAM(0x20000000,0x00001000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: MB058_MM32F0040 +hex
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=5
  c define: USE_STDPERIPH_DRIVER
  c include: .\App\Inc;.\Board\Inc;.\Doc;.\Lib\HAL_Lib\Inc;.\Lib\Core\KEIL_Core;.\Lib\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group App
    ./App/: hci.c main.c music.c
  group Board
    ./Board/: bsp.c bsp_adc.c bsp_beep.c bsp_delay.c bsp_eeprom.c bsp_flash.c bsp_key.c bsp_led.c bsp_uart.c
  group HAL_Lib
    ./Lib/HAL_Lib/Src/: hal_adc.c hal_comp.c hal_crc.c hal_dbg.c hal_div.c hal_dma.c hal_exti.c hal_flash.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_misc.c hal_pwr.c hal_rcc.c hal_spi.c hal_tim.c hal_uart.c hal_uid.c hal_ver.c hal_wwdg.c
  group STARTUP
    ./Lib/CMSIS/: system_mm32spin0x_q.c
    ./Lib/CMSIS/KEIL_StartAsm/: startup_mm32spin0x_q_keil.s
